File: DingoPDM/I2C.kicad_sch (KiCad schematic)
At the start: 10 parts, among them U5 MB85RC256V, U6 MCP9808

Commit message: add DC-DC converter options
Other:
- title: Dingo_PDM -> dingoPDM
