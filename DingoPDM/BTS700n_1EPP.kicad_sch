File: DingoPDM/BTS700n_1EPP.kicad_sch (KiCad schematic)
At the start: 13 parts, among them U8 BTS700n-1EPP

Commit message: add DC-DC converter options
Other:
- title: Dingo_PDM -> dingoPDM
